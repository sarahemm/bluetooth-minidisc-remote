# Repository sarahemm/bluetooth-minidisc-remote

File README.md:

# bluetooth-minidisc-remote
A replacement remote for Sony MD players, with a built-in Bluetooth audio transmitter

## KiCad design hardware/bt-md-remote/bt-md-remote.kicad_pcb

Board: 4 copper layers, 88.3 x 21.7 mm, 122 parts (106 on the bottom side), 87 nets.

Parts:
C1, C9, C10: 4.7uF; C_0402_1005Metric
C2, C3: 10uF; C_0402_1005Metric
C4, C5, C6, C11, C12, C15, C16, C17, C18, C27, C28, C29, C31: 0.1uF; C_0402_1005Metric
C7, C8, C19, C20, C22, C23, C24, C25, C26: 1uF; C_0402_1005Metric
C13, C14: 22pF; C_0402_1005Metric
C30: 0.47uF; C_0402_1005Metric
CN1: USB-C Charging Input; USB_C_Receptacle_Amphenol_12401610E4-2A
CN2: Battery; JST-S2B-PH-SM4-TB
CN3: Remote I/O; 4WIRES
CN4: OLED; AMPHENOL-F3311A7H121014E200
CN5: ICSP; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
CN6: Audio In; 3WIRES
D1: 1N5819; D_SOD-123F
DISP1: Futaba ELW2106AA; FUTABA-ELW2106AA
F1: 80mA Hold; Fuse_0603_1608Metric
FB1: 1k @ 100MHz; L_0402_1005Metric
JP1: Current Measurement; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: Newer Player; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 2.2uH 42mOhm; L_Taiyo-Yuden_NR-40xx
L2: 10uH; L_Taiyo-Yuden_NR-40xx
LED1: Charge Status; LED_RGB_Wuerth-PLCC4_3.2x2.8mm_150141M173100
R1, R2: 5.1k; R_0603_1608Metric
R3, R5, R9, R10, R13, R14: 100k; R_0603_1608Metric
R4: 200k; R_0603_1608Metric
R6: 8.2k; R_0603_1608Metric
R7, R11, R12, R15, R16: 10k; R_0603_1608Metric
R8: 604; R_0603_1608Metric
R17, R18: 100; R_0603_1608Metric
R19: 10m; R_Shunt_Ohmite_LVK12
SW1: Play/Pause; ESWITCH-TL3315
SW2: Display On; CUI-TS22
SW3: Display; CUI-TS22
SW4: Mode; CUI-TS22
SW5: Track Back; CUI-TS22
SW6: Track Forward; CUI-TS22
SW7: Hold; CK-JS203011JAQN
SW8: Volume; SFE-COM-08184
TP1: BT Debug; TestPoint_Pad_1.0x1.0mm
TP2: GND; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TP3: VBUS; TestPoint_Pad_1.0x1.0mm
TP4: +1.8v; TestPoint_Pad_1.0x1.0mm
TP5: +16.5v; TestPoint_Pad_1.0x1.0mm
TP6: Play/Pause LV; TestPoint_Pad_1.0x1.0mm
TP7: Codec IRQ; TestPoint_Pad_1.0x1.0mm
TP8: I2C SCL; TestPoint_Pad_1.0x1.0mm
TP9: I2C SDA; TestPoint_Pad_1.0x1.0mm
TP10: OLED SCLK; TestPoint_Pad_1.0x1.0mm
TP11: OLED Data; TestPoint_Pad_1.0x1.0mm
TP12: OLED CS; TestPoint_Pad_1.0x1.0mm
TP13: OLED D/C; TestPoint_Pad_1.0x1.0mm
TP14: OLED Frame Sync; TestPoint_Pad_1.0x1.0mm
TP15: OLED Reset; TestPoint_Pad_1.0x1.0mm
TP16: Remote Takeover; TestPoint_Pad_1.0x1.0mm
TP17: Remote Send; TestPoint_Pad_1.0x1.0mm
TP18: LCD Data; TestPoint_Pad_1.0x1.0mm
TP19: LCD Direction; TestPoint_Pad_1.0x1.0mm
TP20: HCI Shutdown; TestPoint_Pad_1.0x1.0mm
TP21: HCI RTS; TestPoint_Pad_1.0x1.0mm
TP22: HCI CTS; TestPoint_Pad_1.0x1.0mm
TP23: HCI Data In; TestPoint_Pad_1.0x1.0mm
TP24: HCI Data Out; TestPoint_Pad_1.0x1.0mm
TP25: I2S Word Clock; TestPoint_Pad_1.0x1.0mm
TP26: I2S Bit Clock; TestPoint_Pad_1.0x1.0mm
TP27: I2S Data to Codec; TestPoint_Pad_1.0x1.0mm
TP28: I2S Data from Codec; TestPoint_Pad_1.0x1.0mm
TP29: Battery Alert; TestPoint_Pad_1.0x1.0mm
TP30: Remote Takeover HV; TestPoint_Pad_1.0x1.0mm
TP31: I2C SCL HV; TestPoint_Pad_1.0x1.0mm
TP32: I2C SDA HV; TestPoint_Pad_1.0x1.0mm
TP33: Remote Send HV; TestPoint_Pad_1.0x1.0mm
TR1: 20k; Potentiometer_Bourns_TC33X_Vertical
U1: TLV62568DDC; SOT-23-6
U2: PIC18(L)F47LK42; QFP-44_10x10_Pitch0.8mm
U3: AP3012; SOT-23-5
U4: MCP73831-2-OT; SOT-23-5
U5: TXS0102DCU; VSSOP-8_2.3x2mm_P0.5mm
U6: MCP4017T-503E; SOT-363_SC-70-6
U7, U9: 74LVC1G66; SOT-353_SC-70-5
U8, U12: SN74AUP1T34DCK; SOT-353_SC-70-5
U10, U11: 74LVCH1T45GW; SOT-363_SC-70-6
U13: PAN1326C2; PANASONIC-PAN1326C2
U14: DA7218; DIALOG-DA7218
U15: MAX17260; TDFN-14-1EP_3x3mm_P0.4mm_EP1.78x2.35mm
X1: 7.3728MHz; ABRACON-ABMM2

Connections:
16V5_EN: R10.2, U3.4 (~SHDN)
+1V8: C2.2, C3.2, C4.2, C5.2, C6.2, C15.2, C20.1, C27.2, C28.2, C29.2, CN4.11, CN5.2 (VDD), L1.2, R4.2, R11.2, R12.2, TP4.1, U2.7 (Vdd), U2.28 (Vdd), U5.3 (VCCA), U5.6 (OE), U8.1 (VCCA), U10.1 (VCCA), U10.5 (DIR), U11.1 (VCCA), U12.5 (VCCB), U13.10 (MLDO_OUT), U13.15 (MLDO_IN), U13.22 (Vdd_io), U14.B8 (VDD), U14.C5 (VDD_IO)
+16V5: C8.2, CN4.1, CN4.14, D1.1 (K), R5.2, TP5.1
+BATT: C1.2, C7.2, C10.2, L2.1, R13.2, R19.1, U1.4 (VIN), U3.5 (IN), U4.3 (V_{BAT}), U9.5 (VCC), U10.6 (VCCB), U13.11 (CL1.5_LDO_IN)
/BT_SLOW_CLK: U2.38 (RD0), U13.8 (SLOW_CLK_IN)
/HCI_CTS: TP22.1, U2.44 (RC6/CTS1), U13.3 (HCI_CTS)
/HCI_FROM_BT: TP24.1, U2.1 (RC7/RX1), U13.6 (HCI_TX)
/HCI_RTS: TP21.1, U2.35 (RC1), U13.4 (HCI_RTS)
/HCI_TO_BT: TP23.1, U2.43 (RC5), U13.5 (HCI_RX)
/HCI_~SHUTD: TP20.1, U2.32 (RC0), U13.16 (~SHUTD)
/I2C_FROM_CODEC: TP28.1, U13.18 (AUD_IN), U14.C9 (DATOUT)
/I2S_BCLK: TP26.1, U13.19 (AUD_CLK), U14.D6 (BCLK)
/I2S_TO_CODEC: TP27.1, U13.17 (AUD_OUT), U14.C7 (DATIN)
/I2S_WCLK: TP25.1, U13.7 (AUD_FSYNC), U14.D8 (WCLK)
/IO/AUD_IN_L_LINE: CN6.1, R15.1
/IO/AUD_IN_R_LINE: CN6.2, R16.2
/IO/I2C_SCL_HV: TP31.1, U5.1 (B2), U6.3 (SCL)
/IO/I2C_SDA_HV: TP32.1, U5.8 (B1), U6.4 (SDA)
/IO/PLAYPAUSE_TR: TR1.2, U9.1
/IO/REMOTE_SEND_HV: TP33.1, U7.4, U8.4 (B)
/IO/REMOTE_TAKEOVER_HV: R13.1, TP30.1, U9.4, U10.4 (B)
/OSC1: C14.1, U2.30 (RA7/OSC1), X1.1
/OSC2: C13.1, U2.31 (RA6/OSC2), X1.3
/Power + Charging/1V8_FB: R3.2, R4.1, U1.6 (FB)
/Power + Charging/16V5_FB: R5.1, R6.2, U3.3 (FB)
/Power + Charging/16V5_SW: D1.2 (A), L2.2, U3.1 (SW)
/Power + Charging/FG_KELVIN_NEG: R19.3, U15.7 (CSN)
/Power + Charging/FG_KEVIN_POS: R19.2, U15.10 (CSPH)
/TX_DBG: TP1.1, U13.2 (TX_DBG)
/UI/PLAYPAUSE_HOLD: SW1.1, SW1.2, SW7.5
AUDIO_IN_L: C25.2, R15.2, R17.1
AUDIO_IN_R: C26.2, R16.1, R18.1
BTN_DISPLAY: SW3.2 (B), U2.27 (RE2)
BTN_DISPLAY_ON: SW2.2 (B), U2.20 (RA1)
BTN_MODE: SW4.2 (B), U2.21 (RA2)
BTN_PLAYPAUSE_HV: SW1.3 (K), SW1.4 (A), TR1.1, U12.2 (A)
BTN_PLAYPAUSE_LV: TP6.1, U2.36 (RC2), U12.4 (B)
BTN_TRK_BCK: SW5.2 (B), U2.22 (RA3)
BTN_TRK_FWD: SW6.2 (B), U2.23 (RA4)
BTN_VOL_DOWN: SW8.2, U2.14 (RB4)
BTN_VOL_PRESS: SW8.T, U2.19 (RA0)
BTN_VOL_UP: SW8.1, U2.15 (RB5)
CODEC_~IRQ: TP7.1, U2.25 (RE0), U14.C13 (~IRQ)
FROM_MD: CN3.2, JP2.2 (B), U11.4 (B)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.2, C22.2, C23.2, C24.2, C27.1, C28.1, C29.1, C30.1, C31.2, CN1.A1 (GND), CN1.A12 (GND), CN1.B1 (GND), CN1.B12 (GND), CN1.S1 (SHIELD), CN2.2, CN2.MP (MountPin), CN3.4, CN4.9, CN4.MP (MountPin), CN5.3 (VSS), CN6.3, FB1.1, LED1.3 (K1), R1.2, R2.2, R3.1, R6.1, R7.1, R9.1, R10.1, R14.2, R17.2, R18.2, SW2.1 (A), SW2.3 (AA), SW2.4 (GND), SW2.5 (GND), SW3.1 (A), SW3.3 (AA), SW3.4 (GND), SW3.5 (GND), SW4.1 (A), SW4.3 (AA), SW4.4 (GND), SW4.5 (GND), SW5.1 (A), SW5.3 (AA), SW5.4 (GND), SW5.5 (GND), SW6.1 (A), SW6.3 (AA), SW6.4 (GND), SW6.5 (GND), SW7.3, SW8.C, TP2.1, U1.2 (GND), U2.6 (Vss), U2.29 (Vss), U3.2 (GND), U4.2 (V_{SS})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
GNDA: CN4.2, CN4.10, FB1.2
HOLD_ALL: SW7.2, U2.26 (RE1)
HOLD_XCPT_VOL: SW7.4, U2.39 (RD1)
I2C_SCL: R11.1, TP8.1, U2.9 (RB1/INT1/SCL2), U5.4 (A2), U14.C11 (SCL), U15.14 (SCL)
I2C_SDA: R12.1, TP9.1, U2.10 (RB2/INT2/SDA2), U5.5 (A1), U14.D12 (SDA), U15.13 (SDA)
ICSPCLK: CN5.5 (PGC/ICSPCLK), U2.16 (RB6/CTS2/ISCPCLK)
ICSPDAT: CN5.4 (PGD/ICSPDAT), U2.17 (RB7/RX2/ICSPDAT)
MD_LCD: TP18.1, U2.3 (RD5), U11.3 (A)
MD_LCD_DIR: TP19.1, U2.41 (RD3), U11.5 (DIR)
unnamed: CN1.A5 (CC1), R1.1
unnamed: CN1.B5 (CC2), R2.1
unnamed: CN2.1, F1.1
unnamed: C11.1, CN4.12
unnamed: C12.1, CN4.13
unnamed: F1.2, JP1.1 (A)
unnamed: JP2.1 (A), R14.1
unnamed: LED1.1 (A1), LED1.4 (K2), R8.1
unnamed: L1.1, U1.3 (SW)
unnamed: R7.2, U4.5 (PROG)
unnamed: R8.2, U4.1 (STAT)
unnamed: U6.5 (B), U7.1
unnamed: C22.1, U14.A7 (DACREF)
unnamed: C25.1, U14.A15 (MIC1_P/DMIC1CLK)
unnamed: C26.1, U14.D16 (MIC2_P/DMIC2CLK)
unnamed: C19.2, U14.D4 (VDDDIG)
unnamed: C23.1, U14.A9 (VMID)
unnamed: C24.1, U14.A11 (VREF)
unnamed: C30.2, U15.11 (REG)
OLED_DATA: CN4.8, TP11.1, U2.42 (RC4/SDA1/SDI1)
OLED_DC: CN4.6, TP13.1, U2.40 (RD2)
OLED_FR: CN4.3, TP14.1, U2.11 (RB3)
OLED_SCLK: CN4.7, TP10.1, U2.37 (RC3/SCL1/SCK1)
OLED_~CS: CN4.4, TP12.1, U2.24 (RA5/SS1)
OLED_~RESET: CN4.5, TP15.1, U2.4 (RD6)
RAW_BATT+: C31.1, JP1.2 (B), R19.4, U15.6 (BATT)
REMOTE_SEND: TP17.1, U2.5 (RD7), U8.2 (A)
REMOTE_TAKEOVER: TP16.1, U2.2 (RD4), U10.3 (A)
TO_MD: CN3.3, U7.2, U9.2
VBUS: C9.2, CN1.A4 (VBUS), CN1.A9 (VBUS), CN1.B4 (VBUS), CN1.B9 (VBUS), LED1.2 (A2), TP3.1, U4.4 (V_{DD})
VREMOTE: C16.2, C17.2, C18.2, CN3.1, R9.2, SW7.7, U1.1 (EN), U5.7 (VCCB), U6.1 (VDD), U6.6 (W), U7.5 (VCC), U8.5 (VCCB), U11.6 (VCCB), U12.1 (VCCA)
~BATT_ALERT: TP29.1, U2.8 (RB0/INT0), U15.12 (ALRT)
~MCLR/Vpp: CN5.1 (~MCLR/VPP), U2.18 (RE3/~MCLR/Vpp)

## Code that names these connections

File firmware/pins.h:

/* 
 * File:   pins.h
 * Author: sen
 * Description: Definitions of what pins are used for what
 * 
 * Created on September 30, 2023, 4:24 PM
 */

#ifndef PINS_H
#define	PINS_H

#ifdef	__cplusplus
extern "C" {
#endif

/* ------- */
/* BUTTONS */
/* ------- */

#define BTN_VOL_PRESS_PIN   0
#define BTN_VOL_PRESS_PORT  PORTA

#define BTN_VOL_UP_PIN      5
#define BTN_VOL_UP_PORT     PORTB

#define BTN_VOL_DOWN_PIN    4
#define BTN_VOL_DOWN_PORT   PORTB

#define BTN_DISP_ON_PIN     1
#define BTN_DISP_ON_PORT    PORTA

#define BTN_MODE_PIN        2
#define BTN_MODE_PORT       PORTA

#define BTN_TRK_BACK_PIN    3
#define BTN_TRK_BACK_PORT   PORTA

#define BTN_TRK_FWD_PIN     4
#define BTN_TRK_FWD_PORT    PORTA

#define BTN_DISPLAY_PIN     2
#define BTN_DISPLAY_PORT    PORTE

#define BTN_PLAYPAUSE_PIN   2
#define BTN_PLAYPAUSE_PORT  PORTC

/* ----------- */
/* HOLD SWITCH */
/* ----------- */

#define HOLD_EXCEPT_VOL_PIN     1
#define HOLD_EXCEPT_VOL_PORT    PORTD

#define HOLD_ALL_PIN            1
#define HOLD_ALL_PORT           PORTE

/* ------------ */
/* MD INTERFACE */
/* ------------ */

#define REMOTE_TAKEOVER_PIN     4
#define REMOTE_TAKEOVER_TRIS    TRISD
#define REMOTE_TAKEOVER_LAT     LATD

#define REMOTE_SEND_PIN         7
#define REMOTE_SEND_TRIS        TRISD
#define REMOTE_SEND_LAT         LATD

#define MD_LCD_DIR_PIN          3
#define MD_LCD_DIR_TRIS         TRISD
#define MD_LCD_DIR_LAT          LATD

#define MD_LCD_PIN              5
#define MD_LCD_TRIS             TRISD
#define MD_LCD_LAT              LATD
#define MD_LCD_PORT             PORTD

/* ------- */
/* DISPLAY */
/* ------- */
#define OLED_DC_PIN             2
#define OLED_DC_TRIS            TRISD
#define OLED_DC_LAT             LATD

#define OLED_FR_PIN             3
#define OLED_FR_PORT            PORTB

#define OLED_nRESET_PIN         6
#define OLED_nRESET_TRIS        TRISD
#define OLED_nRESET_LAT         LATD

// per Rev001 ECO A
#define OLED_16V_PIN            5
#define OLED_16V_TRIS           TRISB
#define OLED_16V_LAT            LATB

#define OLED_SCLK_PPS           RC3PPS
#define OLED_MOSI_PPS           RC4PPS
#define OLED_nSS_PPS            RA5PPS

/* --------- */
/* BLUETOOTH */       
/* --------- */

#define BT_nSHUTD_PIN           0
#define BT_nSHUTD_TRIS          TRISC
#define BT_nSHUTD_LAT           LATC
    
#define BT_SLOWCLK_PPS          RD0PPS
#define BT_TX_PPS               RC5PPS
#define BT_RTS_PPS              RC1PPS

/* --- */
/* I2C */
/* --- */

#define I2C_TXB     I2C2TXB
#define I2C_RXB     I2C2TXB
#define I2C_CNT     I2C2CNT
#define I2C_ADDR    I2C2ADB1

#ifdef	__cplusplus
}
#endif

#endif	/* PINS_H */

## Commit log

2023-08-27 Power/charging schematics mostly completed
    The 3 power rail converters are designed, and the charger is done other than status LEDs for it.
2023-08-30 Completed charging circuitry schematic
2023-09-02 Added all buttons/switches
2023-09-02 OLED connection and related passives added
2023-09-02 Started layout out the MCU/logic circuitry
2023-09-03 Finished all button-push functionality except hold switch
    This includes the play/pause button which has to be wired directly through a resistor until the player powers up, then the resistor disconnected from the bus and the MCU put on the bus once it's powe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
2023-09-04 Implemented hold switch
    Needed to change it to a DP3T instead of SP3T because one side has to handle Vremote and one GND.
2023-09-04 Fixed design issue with play/pause handling
    Had the B side of a level shifter running at Vremote voltage which will be 0 sometimes. Now running off Vbatt which means an extra ~1uA of all-the-time current draw but that should be fine, we're sti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
2023-09-04 Created symbol for bluetooth tx and started integrating it
2023-09-04 Bluetooth transmitter integration done
2023-09-04 Codec symbol created and integrated into schematic
2023-09-05 Added fuel gauge, schematic is now functionally complete(?)
    Putting battery voltage into an ADC pin was more complicated than I'd previously thought about, so I ended up putting a proper fuel gauge IC onboard.
    I think this completes the schematic other than test points and layout cleanup. Not checklisted yet, I'll do that once I do the last few things.
2023-09-05 Added attenuation to the audio path, added test points
2023-09-06 Some progress on footprint assignment
2023-09-09 Created/assigned footprints for several parts
    Electromechanical and most of the low-pin-count parts are done, just the high-pin-count semiconductor parts left.
2023-09-09 Footprints done for all but codec and BT transceiver
2023-09-10 Footprint for DA7218 codec built and assigned
2023-09-10 All footprints designed and assigned!
2023-09-10 PCB layout started
2023-09-16 Swapped out fuel gauge IC for a more practically-packaged one
    Previous part was small enough that the photo on the datasheet was taken with an SEM. No, I think we'll go with something slightly larger than that.
2023-09-16 Initial component placement complete!
2023-09-16 Routing in progress
2023-09-17 Routing continues...
2023-09-18 Routing continues, switched to 4-layer
    Realized I needed the improved clearance/track widths of 4 layer service anyways for protos, and it was going to be a stretch routing this on a 2-layer design anyways. Switched over to 4 layer which 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
2023-09-21 Routing continues, under 50 airwires to go
2023-09-23 Routing continues, under 40 airwires to go
2023-09-23 Routing continues, 25 airwires to go
2023-09-23 Initial routing complete!
2023-09-23 Fixed a bunch of track widths and cleaned up all DRC errors
2023-09-23 Basic silk completed
2023-09-24 Slikscreen done and initial PCB checklist done
2023-09-26 Added strich to board and flipped a bunch of upside down text
2023-09-30 Cleaned up a few silkscreen issues and board edge, ready for CAM now.
2023-09-30 CAM output complete and checklisted, board outline fixed
2023-09-30 Paste output complete
2023-10-01 Setting up gitignore for adding firmware
2023-10-01 Initial commit of basic firmware skeleton
2023-10-01 Firmware now (in theory) initializes the display
2023-10-07 Basic display and BT init code written
2023-10-07 Config registers set up
2023-10-07 Fuel gauge implementation in progress
2023-10-09 Fuel gauge module initial attempt done-ish

Notices in the files:
hardware/bt-md-remote/bt-md-remote.kicad_pcb:
© sen 2023
